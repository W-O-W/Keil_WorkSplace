# Keil uVision project Project.uvproj, settings and files
target PROJECT (ARM-ADS)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32100E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD_VL, USE_STM32100E_EVAL
  c include: ..\USER;..\BOOT;..\LIB\inc;..\EVAL;..\EVAL\STM32100E_EVAL;..\EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group SRC
    ../USER/: main.c stm32f10x_it.c delay.c MPU6050.c sys.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BOOT
    ../BOOT/: core_cm3.c system_stm32f10x.c
  group START
    ../STARTUP/: startup_stm32f10x_ld_vl.s
  group DOC
    ./: readme.txt
  group EVAL
    ../EVAL/STM32100E_EVAL/: stm32100e_eval_cec.c stm32100e_eval_fsmc_onenand.c stm32100e_eval_fsmc_sram.c stm32100e_eval_ioe.c stm32100e_eval_lcd.c stm32100e_eval.c
    ../EVAL/Common/: stm32_eval_i2c_tsensor.c stm32_eval_spi_flash.c
